# Keil uVision project scanner.uvprojx, settings and files
target scanner (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: scanner +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_PRESENT=1,__FPU_USED=1
  c misc: --C99
  c include: .\STM32F4xx_StdPeriph_Driver\inc; .\CMSIS\Device\ST\STM32F4xx\Include; .\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group MDK_ARM
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group User
    ./User/: main.c stm32f4xx_it.c ticks.c stepper.c laser.c led.c lcd_main.c
